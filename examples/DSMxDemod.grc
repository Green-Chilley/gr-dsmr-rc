options:
  parameters:
    generate_options: qt_gui
    id: top_block
    max_nouts: '00'
    output_language: python
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    min_len: '1'
    rangeType: int
    start: '0'
    step: '5'
    stop: '70'
    value: '10'
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    min_len: '1'
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '5'
  states: {}
- name: f_deviation
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: filename
  id: variable
  parameters:
    value: rootdir+record_file_path+note+"_"+str(int(gui_samp_rate))+"sps_"
  states: {}
- name: gui_samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: samp_rate
    start: 200e3
    step: 1e6
    stop: 56e6
    value: samp_rate
  states: {}
- name: high_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 800e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 400e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: intermediate_samp_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: low_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 800e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 400e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: max_intensity
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    start: '0'
    step: '1'
    stop: '500'
    value: '50'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: note
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@0:1,1,1,1
    label: RECORDING NOTE (press enter to update)
    type: string
    value: RECORDING_NOTE
  states: {}
- name: rec_button
  id: variable_qtgui_push_button
  parameters:
    gui_hint: tabs@0:1,3,1,1
    label: RECORD
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    value: '"data/"'
  states: {}
- name: rootdir
  id: variable
  parameters:
    value: str(os.path.expanduser("~")+"/")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(intermediate_samp_rate/1e6)
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {state: disabled}
- name: timestamp
  id: variable
  parameters:
    value: datetime.datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S')
  states: {}
- name: top_block_fournisseur
  id: variable_function_probe
  parameters:
    block_id: chan_change
    function_name: set_top_block
    poll_rate: '1'
    value: '0'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*f_deviation)
  states: {}
- name: analog_quadrature_demod_cf_1_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*f_deviation)
  states: {state: disabled}
- name: analog_quadrature_demod_cf_1_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*f_deviation)
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename+str(datetime.datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+"_preamble"+".cfile" if rec_button == 1 else "/dev/null"
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: filename+str(datetime.datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+"_sync"+".cfile" if rec_button == 1 else "/dev/null"
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: filename+str(datetime.datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+".cfile" if rec_button == 1 else "/dev/null"
    type: complex
  states: {}
- name: chan_change
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import inspect
      from gnuradio import gr
      import pmt
      import tkinter.ttk as tk
      import os, struct, array
      from fcntl import ioctl
      import sys, tty, termios
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Controller block:
      Recieves decoded data, prints it, follows the channel sequence and sweeps channels 3 to 11 when no signal is detected."""

          def __init__(self, param=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Channel Changer',   # will show up in GRC
                  in_sig=[],
                  out_sig = []
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern("ChannelChange"))
              self.set_msg_handler(pmt.intern("ChannelChange"), self.chanChangeCallback)
              self.top_block = param
              self.channel_data = np.zeros((2,7))
              self.startup = True
              self.next_channel = 3


              """Called when a decoded packet is recieved"""
          def chanChangeCallback(self, msg):
              string = ''
              meta = pmt.car(msg) #Extract the metadata
              #self.next_channel = pmt.to_python(pmt.dict_ref(meta,pmt.intern("Next channel"),pmt.PMT_NIL))
              #self.top_block.set_channel(self.next_channel)   #This call should be done as soon as possible to avoid issues with channel switch delays

              radio_id1 = pmt.to_python(pmt.dict_ref(meta,pmt.intern("Radio id1"),pmt.PMT_NIL))
              radio_id2 = pmt.to_python(pmt.dict_ref(meta,pmt.intern("Radio id2"),pmt.PMT_NIL))
              data = pmt.cdr(msg)         #Data should contain a 23 byte array with the channel sequence to follow.
              if not pmt.is_u8vector(data):
                  print('Invalid message type')
                  return
              for item in pmt.to_python(data):
                  string = string + str(item) + ' '               #update GUI
                  self.window.detectedLabel.config(text = string)
              string = ''
              for i in range(0,7):
                  #tmp = pmt.to_python(pmt.dict_ref(meta,pmt.intern("0 "+str(i)),pmt.PMT_NIL))
                  #if tmp:
                  #    self.channel_data[0][i] = tmp
                  #tmp = pmt.to_python(pmt.dict_ref(meta,pmt.intern("1 "+str(i)),pmt.PMT_NIL))     #Extract data coming from a potential 2nd packed (if more than 7 channels are being transmitted) unused
                  tmp = pmt.to_python(pmt.dict_ref(meta,pmt.intern(str(i)),pmt.PMT_NIL))
                  # print(str(i) +" " + str(tmp) + " ")
                  if tmp:
                      self.channel_data[0][i] = int(tmp)
                  else:
                      self.channel_data[0][i] = 8192
                  string = string + "CH" + str(i) + " ID " + str(int(self.channel_data[0][i]) >> 12) + ": " + '{:03.2f}'.format(((int(self.channel_data[0][i]) & 0xfff)/2048.0) -1) + " | "
              self.window.channelInfoLabel.config(text = string)      #update GUI
              self.has_detected_signal = True

          """Called once a second"""
          def set_top_block(self):
              prev_frame = inspect.currentframe().f_back
              block = prev_frame.f_locals["self"]
              if self.startup:                    #Inititalize. If done in the __init__ function, GRC will try to call it before runtime and will crash (or do something bad) GRC does not like treads and don't know top_block
                  self.has_detected_signal = True
                  self.top_block = block
                  self.startup = False
                  def launchWindow():                 #Setup GUI
                      self.window = ui(self)
                      self.window.master.title('DSMx Decoder')
                      self.window.mainloop()
                  self._window_thread = threading.Thread(target=launchWindow)
                  self._window_thread.daemon = True
                  self._window_thread.start()

              if not self.has_detected_signal:
                  print('No signal found in 1s, changing channel')
                  self.next_channel = self.sweep_channel(self.next_channel)
                  self.window.detectedLabel.config(text = "Sweeping.")
                  self.window.channelInfoLabel.config(text = "Current channel: "+str(self.next_channel))
                  #self.top_block.set_channel(self.next_channel)
              self.has_detected_signal = False

          def sweep_channel(self, current):
              current = current + 1
              if current > 11:
                  current = 3
              return current

          def work(self, input_items, output_items): #Useless
              return len(input_items[0])



      class ui(tk.Frame):
          def __init__(self, calling, master=None):
              tk.Frame.__init__(self, master)
              self.config(height = 100, width = 1500)
              self.grid()
              self.createWidgets()
              self.calling = calling

          def createWidgets(self):
              self.freqLabel = tk.Label()
              self.freqLabel.grid()
              self.detectedLabel = tk.Label(text=" ")
              self.detectedLabel.grid()
              self.channelInfoLabel = tk.Label(text=" No signal found..  ")
              self.channelInfoLabel.grid()
              self.freqLabel.bind_all('<KeyPress-Return>', self._enterHandler)        #Unused but useful in case of user interaction
              self.freqLabel.bind_all('<KeyPress-Escape>', self._escapeHandler)

          def _enterHandler(self,event):
              self.calling.input_key = 'enter'
          def _escapeHandler(self,event):
              self.calling.input_key = 'escape'
    param: '1'
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_1_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_1_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1100110011001100110011001100110011001100110011001100110011001100'
    tagname: PreambleFound
    threshold: '8'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1100110011001100110011001100110011001100110011001100110011001100'
    tagname: PreambleFound
    threshold: '8'
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1100110011001100110011001100110011001100110011001100110011001100'
    tagname: PreambleFound
    threshold: '8'
    type: byte
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.005'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.005'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.005'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {state: disabled}
- name: dsmx_Despreader_0
  id: dsmx_Despreader
  parameters: {}
  states: {}
- name: dsmx_Despreader_0_0
  id: dsmx_Despreader
  parameters: {}
  states: {state: disabled}
- name: dsmx_Despreader_0_0_0
  id: dsmx_Despreader
  parameters: {}
  states: {state: disabled}
- name: dsmx_bindListener_0
  id: dsmx_bindListener
  parameters: {}
  states: {state: disabled}
- name: dsmx_preambleDetection_0
  id: dsmx_preambleDetection
  parameters:
    channel: channel
  states: {}
- name: dsmx_preambleDetection_0_0
  id: dsmx_preambleDetection
  parameters:
    channel: channel-1
  states: {state: disabled}
- name: dsmx_preambleDetection_0_0_0
  id: dsmx_preambleDetection
  parameters:
    channel: channel+1
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import csv
      import time
      import os

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """A python block that takes in values from channels and outputs them as a graph"""

          def __init__(self, param=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Graph',   # will show up in GRC
                  in_sig=[],
                  out_sig = []
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.param = param
              self.message_port_register_in(pmt.intern("Value"))
              self.set_msg_handler(pmt.intern("Value"), self.graph_values)
              self.channel_data = np.zeros((2,7))
              self.header_written = False
              self.start_time = time.time()

          def elapsed_time(self):
              curr_time = time.time() - self.start_time
              return (curr_time)
          
          def graph_values(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)
              if not pmt.is_u8vector(data):
                  print("Invalid message type")
                  return
              path = 'channel_data.csv2'
              with open(path, 'a+', newline='', encoding='utf-8') as channel_csv:
                  c = csv.writer(channel_csv)
                  if not self.header_written:
                      c.writerow( ['CH0', 'CH1', 'CH2', 'CH3', 'CH4', 'CH5', 'CH6', 'Time'] )
                      self.header_written = True
                  for i in range(0,7):
                      tmp = pmt.to_python(pmt.dict_ref(meta, pmt.intern(str(i)), pmt.PMT_NIL))
                      if tmp:
                          self.channel_data[0][i] = int(tmp)
                      else:
                          self.channel_data[0][i] = 8192
                  curr_time = self.elapsed_time()

                  the_data = list()
                  for i in range(0,7):
                      the_data.append('{:03.2f}'.format(((int(self.channel_data[0][i]) & 0xfff)/2048.0) -1))
                  the_data.append(curr_time)
                  c.writerow(the_data)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.param
              return len(output_items[0])
    param: '1'
  states: {state: disabled}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-2e6'
    decim: '1'
    samp_rate: samp_rate
    taps: low_taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2e6
    decim: '1'
    samp_rate: samp_rate
    taps: high_taps
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_3
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.6e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.4e6
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: tabs@0:0,3,1,1
    label: '"RED=RECORDING"'
    offColor: green
    onColor: red
    position: '2'
    state: True if rec_button == 1 else False
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: ((channel+1) * 1e6) + 2.4e9
    fftsize: '4096'
    rate: '30'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    label1: Recovered Bits
    label2: Raw Data
    name: '"DSMR Signal"'
    nconnections: '2'
    size: '12000'
    srate: 1e6
    tr_delay: '.0001'
    tr_level: '1.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"PreambleFound"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Recovered Bits
    label2: Raw Data
    name: '"rx low Signal"'
    nconnections: '2'
    size: '12000'
    srate: 1e6
    tr_delay: '.0001'
    tr_level: '1.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"PreambleFound"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Recovered Bits
    label2: Raw Data
    name: '"rx high Signal"'
    nconnections: '2'
    size: '12000'
    srate: 1e6
    tr_delay: '.0001'
    tr_level: '1.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"PreambleFound"'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: gui_samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: tabs@0
    int_max: max_intensity
    int_min: '-200'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,7,4
    label0: Tab 0
    num_tabs: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: ((channel+1) * 1e6) + 2.4e9
    clock_rate: '0.0'
    dev_args: '""'
    gain0: RX_gain
    rx_agc0: Disabled
    samp_rate: gui_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: symbol_sync
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: symbol_sync-RX-low
  states: {state: disabled}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: symbol_sync-RX-high
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: preamble
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: preamble-RX-low
  states: {state: disabled}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: preamble-RX-high
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: preamble
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: preamble
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: preamble-RX-low
  states: {state: disabled}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: preamble-RX-high
  states: {state: disabled}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: preamble
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: symbol_sync
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: symbol_sync-RX-low
  states: {state: disabled}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: symbol_sync
  states: {state: disabled}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: symbol_sync-RX-high
  states: {state: disabled}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: symbol_sync
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_1, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_1, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_1_0, '0', digital_symbol_sync_xx_0_0, '0']
- [analog_quadrature_demod_cf_1_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [blocks_char_to_float_0_1, '0', virtual_sink_1, '0']
- [blocks_char_to_float_0_1_0, '0', virtual_sink_1_0, '0']
- [blocks_char_to_float_0_1_0_0, '0', virtual_sink_1_0_0, '0']
- [digital_binary_slicer_fb_1, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_1_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [digital_binary_slicer_fb_1_0_0, '0', digital_correlate_access_code_tag_xx_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', dsmx_bindListener_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', dsmx_preambleDetection_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', blocks_char_to_float_0_1_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', dsmx_preambleDetection_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0_0, '0', blocks_char_to_float_0_1_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0_0, '0', dsmx_preambleDetection_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_1, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_binary_slicer_fb_1_0, '0']
- [digital_symbol_sync_xx_0_0, '0', virtual_sink_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_binary_slicer_fb_1_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', virtual_sink_0_0_0, '0']
- [dsmx_Despreader_0, pdus, chan_change, ChannelChange]
- [dsmx_Despreader_0, pdus, epy_block_0, Value]
- [dsmx_preambleDetection_0, pdus, dsmx_Despreader_0, Msg]
- [dsmx_preambleDetection_0_0, pdus, dsmx_Despreader_0_0, Msg]
- [dsmx_preambleDetection_0_0_0, pdus, dsmx_Despreader_0_0_0, Msg]
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_quadrature_demod_cf_1_0_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_1, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0_1, '0']
- [uhd_usrp_source_0, '0', fosphor_glfw_sink_c_0, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1_1, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_1_1_0, '0']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_1_1_0_0, '0']
- [virtual_source_0_2, '0', blocks_file_sink_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_1_1, '1']
- [virtual_source_1_0, '0', qtgui_time_sink_x_1_1_0, '1']
- [virtual_source_1_0_0, '0', qtgui_waterfall_sink_x_1, '1']
- [virtual_source_1_0_1, '0', qtgui_time_sink_x_1_1_0_0, '1']
- [virtual_source_1_1, '0', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
